# Keil uVision project application.uvprojx, settings and files
target application (5060750::V5.06 update 6 (build 750)::.\ARM_Compiler_5.06u6)
  device: CIU32L051C8Tx HED
  pack: HED.CIU32L0xx_DFP.1.2.6
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: app.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CIU32L051
  c include: .\CMSIS\Core;.\CMSIS\Device;.\Inc\System;.\Inc\Bsp;..\product;.\Inc\LCD;.\Inc\Channel;.\Inc\Sleep;.\Inc\Timer;.\Inc\Key;.\drivers\inc;.\Inc\Usart;.\Inc\Procotol;.\Inc\Upgrade
  library: MicroLIB
  memory RVCT4: ROM 0x8001800 size 0x7400
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Bsp
    ./Src/Bsp/: bsp.c bsp_flash.c bsp_iwdg.c bsp_lcd.c bsp_rtc.c bsp_lptimer.c bsp_usart.c bsp_gpio.c bsp_timer.c
  group System
    ./Src/System/: application.c system.c system_info.c factory.c
  group CMSIS
    ./CMSIS/Device/: system_ciu32l051.c
  group Startup
    ./Startup/: startup_ciu32l051.s
  group Drivers
    ./drivers/src/: ciu32l051_std.c ciu32l051_std_dma.c ciu32l051_std_exti.c ciu32l051_std_flash.c ciu32l051_std_gpio.c ciu32l051_std_lcd.c ciu32l051_std_lptim.c ciu32l051_std_rcc.c ciu32l051_std_pmu.c ciu32l051_std_rtc.c ciu32l051_std_tim.c ciu32l051_std_lpuart.c ciu32l051_std_usart.c
  group RTC
    ./Src/RTC/: rtc.c
  group Time
    ./Src/Timer/: lptimer.c time.c
  group Lcd
    ./Src/LCD/: lcd.c
  group Channel
    ./Src/Channel/: Channel.c
  group Key
    ./Src/Key/: Key.c
  group Sleep
    ./Src/Sleep/: Sleep.c
  group upgrade
    ./Src/Upgrade/: upgrade.c
  group protocol
    ./Src/Protocol/: protocol.c
  group usart
    ./Src/Usart/: Usart.c
