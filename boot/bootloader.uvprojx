# Keil uVision project bootloader.uvprojx, settings and files
target boot (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CIU32L051C8Tx HED
  pack: HED.CIU32L0xx_DFP.1.2.6
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CIU32L051
  c include: .\Inc\System;.\CMSIS\Device;.\drivers\inc;.\CMSIS\Core;.\CMSIS\Device;.\Inc\Bsp;..\product;.\Inc\Upgrade
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x1f00
  memory RVCT10: RAM 0x20001f00 size 0x100
  group Bsp
    ./Src/Bsp/: bsp.c bsp_flash.c bsp_iwdg.c
  group Drivers
    ./Drivers/src/: ciu32l051_std.c ciu32l051_std_flash.c ciu32l051_std_pmu.c ciu32l051_std_tim.c ciu32l051_std_gpio.c ciu32l051_std_lptim.c ciu32l051_std_rcc.c ciu32l051_std_rtc.c
  group System
    ./Src/System/: boot.c system.c system_info.c
    ./Src/Upgrade/: crc32.c
  group Startup
    ./Startup/: startup_ciu32l051.s
  group CMSIS
    ./CMSIS/Device/: system_ciu32l051.c
